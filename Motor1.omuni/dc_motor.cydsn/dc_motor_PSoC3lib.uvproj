# Keil uVision project dc_motor_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: dc_motor_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h Clock_1.c Clock_1.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h PWM_A.c PWM_A.h PWM_A_PM.c BHI.c BHI.h BHI_aliases.h BLI.c BLI.h BLI_aliases.h motor_dis.c motor_dis.h motor_dis_aliases.h AHI.c AHI.h AHI_aliases.h ALI.c ALI.h ALI_aliases.h QuadDec_1.c QuadDec_1.h QuadDec_1_PM.c Clock_3.c Clock_3.h QuadDec_1_Cnt16.c QuadDec_1_Cnt16.h QuadDec_1_Cnt16_PM.c B.c B.h B_aliases.h A.c A.h A_aliases.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h isr_2.c isr_2.h Clock_4.c Clock_4.h LIN_1.c LIN_1.h LIN_1_INT.c LIN_1_UART.c LIN_1_UART.h LIN_1_UART_PM.c LIN_1_UART_INT.c LIN_1_UART_BOOT.c LIN_1_IntClk.c LIN_1_IntClk.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: dc_motor_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
